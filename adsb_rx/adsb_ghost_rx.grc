<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>adsb_ghost</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Rs</value></param>
<param><key>value</key><value>2e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fc</value></param>
<param><key>value</key><value>1090e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>preamble</value></param>
<param><key>value</key><value>0xA140</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>12e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sps</value></param>
<param><key>value</key><value>int(samp_rate / Rs)</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>threshold</value></param>
<param><key>value</key><value>-0.43</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-1.0</value></param>
<param><key>step</key><value>0.01</value></param>
<param><key>stop</key><value>1.0</value></param>
</block>
<block>
<key>blocks_add_const_vxx</key>
<param><key>id</key><value>blocks_add_const_vxx_0</value></param>
<param><key>const</key><value>threshold</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_add_const_vxx</key>
<param><key>id</key><value>blocks_add_const_vxx_1</value></param>
<param><key>const</key><value>-1</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_char_to_float</key>
<param><key>id</key><value>blocks_char_to_float_0</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blocks_complex_to_mag</key>
<param><key>id</key><value>blocks_complex_to_mag_0</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>2</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>digital_binary_slicer_fb</key>
<param><key>id</key><value>digital_binary_slicer_fb_0</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>epy_block_1</value></param>
<param><key>access_code</key><value>'111111000000111111000000000000000000000000111111000000111111000000000000000000000000000000000000'</value></param>
<param><key>_source_code</key><value>"""
Embedded Python Blocks:
Each time this file is saved, GRC will instantiate the first class it finds
to get ports and parameters of your block. The arguments to __init__  will
be the parameters. All of them are required to have default values!
"""

import numpy as np
from gnuradio import gr
import adsb_dec



class blk(gr.basic_block):
    def __init__(self, access_code=None, payload_length=100):
        gr.basic_block.__init__(
            self,
            name='Correlator',
            in_sig=[np.float32],
            out_sig=[np.float32]
        )

        self.category = ''
        self.callsign = ''
        self.position_message = ''
        self.position = ''
        self.access_code = access_code
        self.payload_length = payload_length
        self.corr = 0
        self.velocity = 0

        self.set_min_output_buffer(2**16)


    def general_work(self, input_items, output_items):

        L_in = len(input_items[0])

        if L_in &lt; 10000 :
            return 0

        access_code_binary = np.array([2*int(b)-1 for b in self.access_code], dtype=np.int)

        corr = np.correlate(input_items[0], access_code_binary)

        if np.max(corr) &gt; 90:
            corr = corr.tolist()
            begin = corr.index(max(corr)) + 96
            L_payload = self.payload_length
            samples = ''
            decoded_message = ''

            try:
                reshaped_samples = np.reshape(input_items[0][begin: begin + L_payload], (224, 6))
            except ValueError:
                print("Need more samples. Waiting... ", len(input_items[0]))
                self.consume(0, L_in)
                return 0

            reshaped_samples = reshaped_samples.sum(1)

            counter = 0
            for item in reshaped_samples:
                if item &gt; 0:
                    output_items[0][counter] = 1.0
                    samples = samples + '1'
                else:
                    output_items[0][counter] = 0.0
                    samples = samples + '0'
                counter += 1

            for index in range(0, 223, 2):
                if samples[index] == '0' and samples[index + 1] == '1':
                    decoded_message = decoded_message + '0'
                else:
                    decoded_message = decoded_message + '1'

            decoded_message_hex = hex(int(decoded_message, 2))
            decoded_message_hex = decoded_message_hex[2:-1]

            type_code = adsb_dec.typecode(decoded_message_hex)

            if type_code &lt; 1 or type_code &gt; 4:
                pass
            else:
                self.category = adsb_dec.category(decoded_message_hex)
                self.callsign = adsb_dec.callsign(decoded_message_hex)

            if 5 &lt;= type_code &lt;= 8:
                self.velocity = surface_velocity(decoded_message_hex)

            elif type_code == 19:
                self.velocity = airborne_velocity(decoded_message_hex)

            if (9 &lt;= type_code &lt;= 18 and 9 &lt;= type_code &lt;= 18):
                if self.position_message and (self.position_message != decoded_message_hex):
                    print(adsb_dec.oe_flag(self.position_message))
                    print(adsb_dec.oe_flag(decoded_message_hex))
                    if (adsb_dec.oe_flag(self.position_message) == 0) and (adsb_dec.oe_flag(decoded_message_hex) == 1):
                        self.position = adsb_dec.position(self.position_message, decoded_message_hex, 1, 11)
                        self.position_message = ''
                    else:
                        self.position_message = ''

                else:
                    self.position_message = ''
                    self.position_message = decoded_message_hex
            else:
                pass

            print("CATEGORY: " + str(self.category) + "          CALLSIGN: " + str(self.callsign) + "          POSITION: " + str(self.position) + "          VELOCITY: " + str(self.velocity))
            self.consume(0, L_payload + len(self.access_code))
            return 224

        else:
            self.consume(0, L_in)

        return 0
</value></param>
<param><key>payload_length</key><value>224*6</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import numpy as np</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>marker1</key><value>0</value></param>
<param><key>size</key><value>2048</value></param>
<param><key>srate</key><value>12000000</value></param>
<param><key>tr_mode</key><value>qtgui.TRIG_MODE_AUTO</value></param>
<param><key>type</key><value>float</value></param>
<param><key>update_time</key><value>0.05</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0_1</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>marker1</key><value>0</value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>marker2</key><value>0</value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>size</key><value>2048</value></param>
<param><key>srate</key><value>12000000</value></param>
<param><key>tr_mode</key><value>qtgui.TRIG_MODE_AUTO</value></param>
<param><key>type</key><value>float</value></param>
<param><key>update_time</key><value>0.05</value></param>
<param><key>ymax</key><value>1.2</value></param>
<param><key>ymin</key><value>-1.2</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0</value></param>
<param><key>decim</key><value>int(2.88e6)</value></param>
<param><key>interp</key><value>int(12e6)</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>rtlsdr_source</key>
<param><key>id</key><value>rtlsdr_source_0</value></param>
<param><key>bb_gain0</key><value>30</value></param>
<param><key>freq0</key><value>fc - 10e3</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>if_gain0</key><value>30</value></param>
<param><key>gain0</key><value>30</value></param>
<param><key>args</key><value></value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>2.88e6</value></param>
<param><key>sync</key><value></value></param>
</block>
<connection><source_block_id>blocks_add_const_vxx_0</source_block_id><sink_block_id>digital_binary_slicer_fb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_const_vxx_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_const_vxx_1</source_block_id><sink_block_id>epy_block_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_const_vxx_1</source_block_id><sink_block_id>qtgui_time_sink_x_0_0_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_char_to_float_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_0</source_block_id><sink_block_id>rational_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>blocks_add_const_vxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_binary_slicer_fb_0</source_block_id><sink_block_id>blocks_char_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>epy_block_1</source_block_id><sink_block_id>blocks_null_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>epy_block_1</source_block_id><sink_block_id>qtgui_time_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>blocks_add_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rtlsdr_source_0</source_block_id><sink_block_id>blocks_complex_to_mag_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
