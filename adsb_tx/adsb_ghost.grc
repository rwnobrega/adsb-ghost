<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>adsb_ghost</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Rs</value></param>
<param><key>value</key><value>2e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fc</value></param>
<param><key>value</key><value>1090e6</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>freq_corr</value></param>
<param><key>value</key><value>0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-100</value></param>
<param><key>step</key><value>0.5</value></param>
<param><key>stop</key><value>100</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>preamble</value></param>
<param><key>value</key><value>0xA140</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>12e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sps</value></param>
<param><key>value</key><value>int(samp_rate / Rs)</value></param>
</block>
<block>
<key>analog_const_source_x</key>
<param><key>id</key><value>analog_const_source_x_0</value></param>
<param><key>const</key><value>0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>freq</key><value>10e3</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>blocks_complex_to_float</key>
<param><key>id</key><value>blocks_complex_to_float_0</value></param>
</block>
<block>
<key>blocks_float_to_complex</key>
<param><key>id</key><value>blocks_float_to_complex_0</value></param>
</block>
<block>
<key>blocks_float_to_int</key>
<param><key>id</key><value>blocks_float_to_int_1</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blocks_int_to_float</key>
<param><key>id</key><value>blocks_int_to_float_0</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_repack_bits_bb</key>
<param><key>id</key><value>blocks_repack_bits_bb_0</value></param>
<param><key>k</key><value>8</value></param>
<param><key>l</key><value>1</value></param>
<param><key>endianness</key><value>gr.GR_MSB_FIRST</value></param>
</block>
<block>
<key>blocks_repack_bits_bb</key>
<param><key>id</key><value>blocks_repack_bits_bb_0_0</value></param>
<param><key>k</key><value>8</value></param>
<param><key>l</key><value>1</value></param>
<param><key>endianness</key><value>gr.GR_MSB_FIRST</value></param>
</block>
<block>
<key>blocks_stream_mux</key>
<param><key>id</key><value>blocks_stream_mux_0</value></param>
<param><key>lengths</key><value>16, 2*112</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>blocks_vector_source_x</key>
<param><key>id</key><value>blocks_vector_source_x_0_0</value></param>
<param><key>type</key><value>int</value></param>
<param><key>repeat</key><value>True</value></param>
<param><key>vector</key><value>tuple(int(x) for x in bin(preamble)[2:])</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>epy_block_0</value></param>
<param><key>_source_code</key><value>"""
Embedded Python Blocks:

Each time this file is saved, GRC will instantiate the first class it finds
to get ports and parameters of your block. The arguments to __init__  will
be the parameters. All of them are required to have default values!
"""

import numpy as np
import encoder
import util
from gnuradio import gr
from subprocess import call

MOVEMENT_CONST = 0.0001
class blk(gr.basic_block):  # other base classes are basic_block, decim_block, interp_block
    """Embedded Python Block example - a simple multiply const"""

    def __init__(self):  # only default arguments here
        """arguments to this function show up as parameters in GRC"""


        gr.basic_block.__init__(
            self,
            name='ADSB encoder',   # will show up in GRC
            in_sig=[],
            out_sig=[np.uint8]
        )

        # if an attribute with the same name as a parameter is found,
        # a callback is registered (properties work, too).

	self.int_to_return = []

    def travel(self, coordinates, alt, icao, current_latitude, current_longitude, plan = None):

        lat_list = []
        lon_list = []

        lat_list.append(current_latitude)
        lon_list.append(current_longitude)
        lat_list.append(current_latitude + MOVEMENT_CONST)
        lon_list.append(current_longitude + MOVEMENT_CONST)

        lat_list.append(coordinates['latitude'])
        lon_list.append(coordinates["longitude"])
        lat_list.append(coordinates["latitude"] + MOVEMENT_CONST)
        lon_list.append(coordinates["longitude"] + MOVEMENT_CONST)

        i = 0
        while i &lt; len(lat_list):
            coordenadas = encoder.cpr_encode(lat_list[i], lon_list[i], 0, 1)
            latitude = encoder.get_lat(coordenadas)
            longitude = encoder.get_long(coordenadas)
            message_position = encoder.aircraft_position('01011000', alt, latitude,
                                                         longitude, '0', icao)

            coordenadas = encoder.cpr_encode(lat_list[i+1], lon_list[i+1], 1, 1)
            latitude = encoder.get_lat(coordenadas)
            longitude = encoder.get_long(coordenadas)
            message_position1 = encoder.aircraft_position('01011000', alt, latitude,
                                                          longitude, '1', icao)
            plan.write(util.hex2bin(message_position))
            plan.write(util.hex2bin(message_position1))

            # coordenadas_dec = adsb_dec.position(message_position,
            #                                     message_position1, 1, 11)
            i = i + 2

    def general_work(self, input_items, output_items):
        if not self.int_to_return:
            icao = "40621D"
            alts = '110000111000'
            plan = open('/home/llucindov/dev/telecom/adsb-ghost/flight_plan_binary.txt', 'w+')
            lock = True
            current_latitude = -27.608339
            current_longitude = -48.633269
            flight_plan = open("flight_plan.txt","r")
            a = flight_plan.readlines()
            list_command = []
            list_value = []

            for i in range(len(a)):
                b = a[i].split(";")
                list_command.append(b[0])
                list_value.append(b[1].rstrip())

            while lock == True:
                for i in range(len(a)):
                    if i == (len(a) - 1):
                        lock = False

                    if list_command[i] == 'travel':
                        destiny_coordinates = list_value[i].split(",")
                        destiny_coordinates = {'latitude': float(destiny_coordinates[0]),
                                               'longitude': float(destiny_coordinates[1])}
                        self.travel(destiny_coordinates, alts, icao, current_latitude, current_longitude, plan)

                    if list_command[i] == 'name':
                        message = encoder.aircraft_id(icao, list_value[i])
                        plan.write(util.hex2bin(message))

                    # if list_command[i] == 'alt':
                    #     destiny_coordinates = {'latitude': current_latitude,'longitude': current_longitude}
                    #     alts = encoder.aircraft_altitude(int(list_value[i]))
                    #     self.travel(self, destiny_coordinates, alts, message, current_latitude, current_longitude, plan)

            plan.close()
            b = open('/home/llucindov/dev/telecom/adsb-ghost/flight_plan_binary.txt', "r")
            c = b.readlines()
            c = str(c)
            c = c[2:(len(c)-2)]
            print(c[0:112])
            print(len(c[0:111]))

            print(c[112:224])
            print(len(c[112:224]))

            print(c[112:112])
            print(len(c[0:111]))

            print(c[112:112])
            print(c[112:112])
            print(c[112:112])
            print(c[112:112])
            print(c[112:112])
            print(c[112:112])
            print(c[112:112])
            print(c[112:112])

            chunks = [c[i:i+8] for i in range(0, len(c), 8)]
            list_int = [int(x, 2) for x in chunks]
            self.int_to_return = list_int
            output_items[0][0] = self.int_to_return.pop(0)
            return 1

        else:
            if self.int_to_return:
                output_items[0][0] = self.int_to_return.pop(0)
                return 1
</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>epy_block_1</value></param>
<param><key>_source_code</key><value>"""
Embedded Python Blocks:

Each time this file is saved, GRC will instantiate the first class it finds
to get ports and parameters of your block. The arguments to __init__  will
be the parameters. All of them are required to have default values!
"""

import numpy as np
from gnuradio import gr


class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
    """Embedded Python Block example - a simple multiply const"""

    def __init__(self, example_param=1.0):  # only default arguments here
        """arguments to this function show up as parameters in GRC"""
        gr.sync_block.__init__(
            self,
            name='ADSB DECODER',   # will show up in GRC
            in_sig=[np.int8],
            out_sig=[]
        )
        # if an attribute with the same name as a parameter is found,
        # a callback is registered (properties work, too).
        self.example_param = example_param


    def forecast(self, noutput_items, ninput_items_required):
        ninput_items_required = 14

    def work(self, input_items, output_items):
        """example: multiply with constant"""
        # print((input_items[0][0:112]))
        # print(len(input_items[0][0:112]))

        self.consume(0, 8)
        return 0
</value></param>
<param><key>example_param</key><value>1.0</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>epy_block_1_0</value></param>
<param><key>_source_code</key><value>"""
Embedded Python Blocks:

Each time this file is saved, GRC will instantiate the first class it finds
to get ports and parameters of your block. The arguments to __init__  will
be the parameters. All of them are required to have default values!
"""

import numpy as np
from gnuradio import gr


class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
    """Embedded Python Block example - a simple multiply const"""

    def __init__(self, example_param=1.0):  # only default arguments here
        """arguments to this function show up as parameters in GRC"""
        gr.sync_block.__init__(
            self,
            name='SNIFFER',   # will show up in GRC
            in_sig=[np.int8],
            out_sig=[]
        )
        # if an attribute with the same name as a parameter is found,
        # a callback is registered (properties work, too).
        self.example_param = example_param


    # def forecast(self, noutput_items, ninput_items_required):
    #     ninput_items_required = 14

    def work(self, input_items, output_items):
        """example: multiply with constant"""

        self.consume(0, 8)
        return 0
</value></param>
<param><key>example_param</key><value>1.0</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>epy_block_2</value></param>
<param><key>_source_code</key><value>"""
Embedded Python Blocks:

Each time this file is saved, GRC will instantiate the first class it finds
to get ports and parameters of your block. The arguments to __init__  will
be the parameters. All of them are required to have default values!
"""

import numpy as np
from gnuradio import gr


class blk(gr.basic_block):  # other base classes are basic_block, decim_block, interp_block
    """Embedded Python Block example - a simple multiply const"""

    def __init__(self):  # only default arguments here
        """arguments to this function show up as parameters in GRC"""
        gr.basic_block.__init__(
            self,
            name='Decoder',   # will show up in GRC
            in_sig=[np.int32],
            out_sig=[np.uint8]
        )
        # self.preambule = '1010000101000000'
        self.preambule = '1010000101000000'
        self.int_to_return = []
        # if an attribute with the same name as a parameter is found,
        # a callback is registered (properties work, too).
    def forecast(self, noutput_items, ninput_items_required):
        ninput_items_required = 2000

    def general_work(self, input_items, output_items):
        #input_items com sinais super amostrados.
        # print("INICIO")
        if len(input_items[0]) &lt; 2000:
            # print("BUFFER SEM TAMANHO SUFICIENTE. Esperando...")
            return 0

        # print("VAI PROCESSAR")
        # print("ITEMS NO BUFFER DE ENTRADA: ", input_items[0])
        #Confirma que ha amostras o suficiente para processar
        if not self.int_to_return:
            # # print("LISTA INTEIROS VAZIA")
            n_sample = 6 #fator de superamostragem
            samples = '' #ira comportar as amostras transformadas em string
            samples_backup = np.empty_like(input_items[0][::n_sample]) #array vazio para comportar as amostras de interesse

            #loop para retirar as superamostragem, atraves do fator de superamostragem
                #1. primeiro se guarda a amostra intocada
                #2. Depois transforma a amostra em string para que possa se buscar o preambulo posteriormente
            sample_counter = 0
            for index in range(n_sample/2, len(input_items[0]) - 1, n_sample):
                if index &gt;= len(samples_backup):
                    break
                samples_backup[sample_counter]= input_items[0][index]
                samples = samples + str((input_items[0][index]))
                sample_counter = sample_counter + 1
            # print("AMOSTRAS SEM SUPERAMOSTRAGEM: ", samples_backup)
            # print("Quantidade de amostras: ", len(samples_backup))

            ppm_array = ''
            decoded_message = ''
            retorno = 0 #ira inidicar o numero de itens a serem retornados
            # print("STRING AMOSTRAS: ", samples)
            if samples.find(self.preambule) != -1: #Confirma se eh possivel encontrar o preambulo
                # # print("ENCONTROU O PREAMBULO")
                #Pega o inicio do preambulo e aponta onde eh o inicio das informacoes
                start_preambule = samples.find(self.preambule)
                start_data = start_preambule + len(self.preambule)

                for i in range(start_data, start_data + 224):
                    ppm_array = ppm_array + str(samples_backup[i])
                    output_items[0][retorno] = samples_backup[i]
                    retorno = retorno + 1

                for index in range(0, 223, 2):

                    if ppm_array[index] == '0' and ppm_array[index + 1] == '1':
                        decoded_message = decoded_message + '0'
                    else:
                        decoded_message = decoded_message + '1'
                # print("DECODED MESSAGE", decoded_message)
                # print("TAMANHO DA DECODED MESSAGE", len(decoded_message))

                first_message = "1000110101000000011000100001110100100000000110001100011001000100010101010100000011001000101010001101100111010110"
                second_message = "1000110101000000011000100001110101011000110000111000000110011000001011111010111000100010110101100101010111111000"

                if decoded_message == first_message:
                    print("PRIMEIRO PACOTE ACHADO")

                if decoded_message == second_message:
                    print("SEGUNDO PACOTE ACHADO")

                chunks = [decoded_message[i:i+8] for i in range(0, len(decoded_message), 8)]
                list_int = [int(x, 2) for x in chunks]
                self.int_to_return = list_int
                output_items[0][0] = self.int_to_return.pop(0)
                self.consume(0, 1440)
                # print("FINAL")
                # print("\n")
                return 1

            else:
                # print("NAO ENCONTROU O PREAMBULO")
                # print("FINAL")
                # print("\n")
                self.consume(0, len(input_items[0]) - 1)
                return 0
        else:
            if self.int_to_return:
                # print("LISTA INTEIRO NAO VAZIA")
                output_items[0][0] = self.int_to_return.pop(0)
                # print("FINAL")
                # print("\n")
                return 1


        # if len(input_items[0]) &lt; 768:
        #     return 0
        #
        # retorno = 0
        # n_sample = 6
        # samples = ''
        # samples_float = np.empty_like(input_items[0][::n_sample])
        #
        # for index in range(n_sample/2, len(input_items[0]) - 1, n_sample):
        #     if index &gt;= len(samples_float):
        #         break
        #     samples_float[index]= input_items[0][index]
        #     samples = samples + str((input_items[0][index].astype(int)))
        #
        # if samples.find(self.preambule) != -1:
        #     start_preambule = samples.find(self.preambule)
        #     start_data = start_preambule + len(self.preambule)
        #     for i in range(start_data, start_data + 112):
        #         if int(samples_float[i].astype(int)) &gt;= 1:
        #             output_items[0][retorno] = 1
        #
        #         else:
        #             output_items[0][retorno] = 0
        #
        #         retorno = retorno + 1
        #     print("FIM: ", samples[0:retorno])
        #     return retorno
        #
        # else:
        #     print("DEU RUIM")
        #     return retorno
</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import numpy as np</value></param>
</block>
<block>
<key>interp_fir_filter_xxx</key>
<param><key>id</key><value>interp_fir_filter_xxx_0</value></param>
<param><key>interp</key><value>sps</value></param>
<param><key>taps</key><value>np.ones(sps)</value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>osmosdr_sink</key>
<param><key>id</key><value>osmosdr_sink_0</value></param>
<param><key>bb_gain0</key><value>30</value></param>
<param><key>corr0</key><value>freq_corr</value></param>
<param><key>freq0</key><value>fc - 10e3</value></param>
<param><key>if_gain0</key><value>30</value></param>
<param><key>gain0</key><value>0</value></param>
<param><key>args</key><value></value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>ppm_mapper</value></param>
<param><key>_source_code</key><value>import numpy as np
from gnuradio import gr


class blk(gr.interp_block):

    def __init__(self):
        gr.interp_block.__init__(
            self,
            name='PPM mapper',
            in_sig=[np.int8],
            out_sig=[np.int32],
            interp=2
        )

    def work(self, input_items, output_items):
        for i, b in enumerate(input_items[0]):
            output_items[0][2*i] = b
            output_items[0][2*i + 1] = not b
        return len(output_items[0])
</value></param>
</block>
<block>
<key>qtgui_number_sink</key>
<param><key>id</key><value>qtgui_number_sink_0</value></param>
<param><key>graph_type</key><value>qtgui.NUM_GRAPH_HORIZ</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>marker1</key><value>0</value></param>
<param><key>size</key><value>2048</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>tr_mode</key><value>qtgui.TRIG_MODE_AUTO</value></param>
<param><key>type</key><value>float</value></param>
<param><key>update_time</key><value>0.05</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0</value></param>
<param><key>stream_id</key><value>virtual</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0</value></param>
<param><key>stream_id</key><value>virtual</value></param>
</block>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_0</source_block_id><sink_block_id>blocks_float_to_int_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_0</source_block_id><sink_block_id>blocks_complex_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_int_1</source_block_id><sink_block_id>epy_block_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_int_to_float_0</source_block_id><sink_block_id>virtual_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0</source_block_id><sink_block_id>osmosdr_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_repack_bits_bb_0</source_block_id><sink_block_id>epy_block_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_repack_bits_bb_0</source_block_id><sink_block_id>ppm_mapper</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_repack_bits_bb_0_0</source_block_id><sink_block_id>epy_block_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_repack_bits_bb_0_0</source_block_id><sink_block_id>qtgui_number_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_mux_0</source_block_id><sink_block_id>blocks_int_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_0_0</source_block_id><sink_block_id>blocks_stream_mux_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>epy_block_0</source_block_id><sink_block_id>blocks_repack_bits_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>epy_block_2</source_block_id><sink_block_id>blocks_repack_bits_bb_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>interp_fir_filter_xxx_0</source_block_id><sink_block_id>blocks_float_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>interp_fir_filter_xxx_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ppm_mapper</source_block_id><sink_block_id>blocks_stream_mux_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>virtual_source_0</source_block_id><sink_block_id>interp_fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
