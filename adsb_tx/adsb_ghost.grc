<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>adsb_ghost</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Rs</value></param>
<param><key>value</key><value>2e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fc</value></param>
<param><key>value</key><value>1090e6</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>freq_corr</value></param>
<param><key>value</key><value>0</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-100</value></param>
<param><key>step</key><value>0.5</value></param>
<param><key>stop</key><value>100</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>preamble</value></param>
<param><key>value</key><value>0xA140</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>12e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sps</value></param>
<param><key>value</key><value>int(samp_rate / Rs)</value></param>
</block>
<block>
<key>analog_const_source_x</key>
<param><key>id</key><value>analog_const_source_x_0</value></param>
<param><key>const</key><value>0</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>freq</key><value>10e3</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>blocks_complex_to_float</key>
<param><key>id</key><value>blocks_complex_to_float_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>blocks_complex_to_mag</key>
<param><key>id</key><value>blocks_complex_to_mag_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>blocks_float_to_complex</key>
<param><key>id</key><value>blocks_float_to_complex_0</value></param>
</block>
<block>
<key>blocks_float_to_int</key>
<param><key>id</key><value>blocks_float_to_int_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blocks_int_to_float</key>
<param><key>id</key><value>blocks_int_to_float_0</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_repack_bits_bb</key>
<param><key>id</key><value>blocks_repack_bits_bb_0</value></param>
<param><key>k</key><value>8</value></param>
<param><key>l</key><value>1</value></param>
<param><key>endianness</key><value>gr.GR_MSB_FIRST</value></param>
</block>
<block>
<key>blocks_stream_mux</key>
<param><key>id</key><value>blocks_stream_mux_0</value></param>
<param><key>lengths</key><value>16, 2*112, 20000</value></param>
<param><key>num_inputs</key><value>3</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>blocks_vector_source_x</key>
<param><key>id</key><value>blocks_vector_source_x_0_0</value></param>
<param><key>type</key><value>int</value></param>
<param><key>repeat</key><value>True</value></param>
<param><key>vector</key><value>tuple(int(x) for x in bin(preamble)[2:])</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>epy_block_0</value></param>
<param><key>_source_code</key><value>"""
Embedded Python Blocks:

Each time this file is saved, GRC will instantiate the first class it finds
to get ports and parameters of your block. The arguments to __init__  will
be the parameters. All of them are required to have default values!
"""

import numpy as np
import encoder
import util
from gnuradio import gr
from subprocess import call

MOVEMENT_CONST = 0.0001
class blk(gr.basic_block):  # other base classes are basic_block, decim_block, interp_block
    """Embedded Python Block example - a simple multiply const"""

    def __init__(self):  # only default arguments here
        """arguments to this function show up as parameters in GRC"""


        gr.basic_block.__init__(
            self,
            name='ADSB encoder',   # will show up in GRC
            in_sig=[],
            out_sig=[np.uint8]
        )

        # if an attribute with the same name as a parameter is found,
        # a callback is registered (properties work, too).

        self.int_to_return = []

    def travel(self, coordinates, alt, icao, current_latitude, current_longitude, plan = None):

        lat_list = []
        lon_list = []


        lat_list.append(current_latitude)
        lon_list.append(current_longitude)

        lat_list.append(current_latitude + MOVEMENT_CONST)
        lon_list.append(current_longitude + MOVEMENT_CONST)


        lat_list = np.linspace(current_latitude, coordinates["latitude"], 1000).tolist()
        lon_list = np.linspace(current_longitude, coordinates["longitude"], 1000).tolist()

        lat_list.append(coordinates['latitude'])
        lon_list.append(coordinates["longitude"])
        lat_list.append(coordinates["latitude"] + MOVEMENT_CONST)
        lon_list.append(coordinates["longitude"] + MOVEMENT_CONST)

        i = 0
        while i &lt; len(lat_list):
            coordenadas = encoder.cpr_encode(lat_list[i], lon_list[i], 0, 1)
            latitude = encoder.get_lat(coordenadas)
            longitude = encoder.get_long(coordenadas)
            message_position = encoder.aircraft_position('01011000', alt, latitude,
                                                         longitude, '0', icao)

            coordenadas = encoder.cpr_encode(lat_list[i+1], lon_list[i+1], 1, 1)
            latitude = encoder.get_lat(coordenadas)
            longitude = encoder.get_long(coordenadas)
            message_position1 = encoder.aircraft_position('01011000', alt, latitude,
                                                          longitude, '1', icao)
            plan.write(util.hex2bin(message_position))
            plan.write(util.hex2bin(message_position1))

            # coordenadas_dec = adsb_dec.position(message_position,
            #                                     message_position1, 1, 11)
            i = i + 2

    def general_work(self, input_items, output_items):
        if not self.int_to_return:
            icao = "40621D"
            alts = '110000111000'
            plan = open('/home/llucindov/dev/telecom/adsb-ghost/flight_plan_binary.txt', 'w+')
            lock = True
            current_latitude = -27.608339
            current_longitude = -48.633269
            flight_plan = open("/home/llucindov/dev/telecom/adsb-ghost/flight_plan.txt","r")
            a = flight_plan.readlines()
            list_command = []
            list_value = []

            for i in range(len(a)):
                b = a[i].split(";")
                list_command.append(b[0])
                list_value.append(b[1].rstrip())

            while lock == True:
                for i in range(len(a)):
                    if i == (len(a) - 1):
                        lock = False

                    if list_command[i] == 'travel':
                        destiny_coordinates = list_value[i].split(",")
                        destiny_coordinates = {'latitude': float(destiny_coordinates[0]),
                                               'longitude': float(destiny_coordinates[1])}
                        self.travel(destiny_coordinates, alts, icao, current_latitude, current_longitude, plan)

                    if list_command[i] == 'name':
                        message = encoder.aircraft_id(icao, list_value[i])
                        plan.write(util.hex2bin(message))

                    # if list_command[i] == 'alt':
                    #     destiny_coordinates = {'latitude': current_latitude,'longitude': current_longitude}
                    #     alts = encoder.aircraft_altitude(int(list_value[i]))
                    #     self.travel(self, destiny_coordinates, alts, message, current_latitude, current_longitude, plan)

            plan.close()
            b = open('/home/llucindov/dev/telecom/adsb-ghost/flight_plan_binary.txt', "r")
            c = b.readlines()
            c = str(c)
            c = c[2:(len(c)-2)]

            chunks = [c[i:i+8] for i in range(0, len(c), 8)]
            list_int = [int(x, 2) for x in chunks]
            self.int_to_return = list_int
            output_items[0][0] = self.int_to_return.pop(0)
            return 1

        else:
            if self.int_to_return:
                output_items[0][0] = self.int_to_return.pop(0)
                return 1
</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>epy_block_1</value></param>
<param><key>access_code</key><value>'111111000000111111000000000000000000000000111111000000111111000000000000000000000000000000000000'</value></param>
<param><key>_source_code</key><value>"""
Embedded Python Blocks:
Each time this file is saved, GRC will instantiate the first class it finds
to get ports and parameters of your block. The arguments to __init__  will
be the parameters. All of them are required to have default values!
"""

import numpy as np
from gnuradio import gr
import adsb_dec



class blk(gr.basic_block):  # other base classes are basic_block, decim_block, interp_block
    def __init__(self, access_code=None, payload_length=100, threshold=0):  # only default arguments here
        """arguments to this function show up as parameters in GRC"""
        gr.basic_block.__init__(
            self,
            name='My Correlator Block',   # will show up in GRC
            in_sig=[np.float32],
            out_sig=[np.float32]
        )
        # if an attribute with the same name as a parameter is found,
        # a callback is registered (properties work, too).

        self.category = ''
        self.callsign = ''
        self.position_message = ''
        self.position = ''
        self.access_code = access_code
        self.payload_length = payload_length
        self.threshold = threshold
        self.mode = 'find'

        self.set_min_output_buffer(2**16)


    def general_work(self, input_items, output_items):
        if self.mode == 'output':
            return self.general_work_output(input_items, output_items)
        elif self.mode == 'find':
            return self.general_work_find(input_items, output_items)

    def general_work_output(self, input_items, output_items):
        L_in = len(input_items[0])
        L_out = len(output_items[0])
        L_payload = self.payload_length

        if L_in &lt; L_payload or L_out &lt; L_payload:
            return 0

        output_items[0][:L_payload] = input_items[0][:L_payload]
        self.consume(0, L_payload)

        n_sample = 6
        samples = ''
        sample_counter = 0
        decoded_message = ''

        for index in range(n_sample/2, len(input_items[0]), n_sample):
            if input_items[0][index] &gt; 0.5:
                samples = samples + '1'
            else:
                samples = samples + '0'

        for index in range(0, 223, 2):
            if samples[index] == '0' and samples[index + 1] == '1':
                decoded_message = decoded_message + '0'
            else:
                decoded_message = decoded_message + '1'

        # print("DECODED_MESSAGE:    ", decoded_message)


        decoded_message_hex = hex(int(decoded_message, 2))
        decoded_message_hex = decoded_message_hex[2:-1]

        type_code = adsb_dec.typecode(decoded_message_hex)

        if type_code &lt; 1 or type_code &gt; 4:
            pass
        else:
            self.category = adsb_dec.category(decoded_message_hex)
            self.callsign = adsb_dec.callsign(decoded_message_hex)

        if (9 &lt;= type_code &lt;= 18 and 9 &lt;= type_code &lt;= 18):
            if self.position_message:
                self.position = adsb_dec.airborne_position(self.position_message, decoded_message_hex, 1, 2)
                self.position_message = ''
            else:
                self.position_message = decoded_message_hex
        else:
            pass

        print("CATEGORY: " + str(self.category) + "          CALLSIGN: " + str(self.callsign) + "          POSITION: " + str(self.position))


        self.mode = 'find'

        return L_payload

        # message_1 = "1000110101000000011000100001110100100000000110001100011001000100010101010100000011001000101010001101100111010110"
        # message_2 = "1000110101000000011000100001110101011000110000111000000110011000001011111010111000100010110101100101010111111000"
        # message_3 = "1000110101000000011000100001110101011000110000111000010111100110101110111111001101001111011001010001000011010000"
        # message_4 = "1000110101000000011000100001110101011000110000111000001111111001101010010111110011110100001111110000010010010111"
        # message_5 = "1000110101000000011000100001110101011000110000111000010001001111000111011100010111001110111011011101100000100110"
        # message_6 = "1000110101000000011000100001110101011000110000111000000110011000001011111010111000100010110101100101010111111000"
        # message_7 = "1000110101000000011000100001110101011000110000111000010111100110101110111111001101001111011001010001000011010000"
        # message_8 = "1000110101000000011000100001110101011000110000111000001000101111001010111010101000010111110011110001100001010011"
        # message_9 = "1000110101000000011000100001110101011000110000111000011010011101010101011011011100011000101000110101011111110011"
        # message_10 = "1000110101000000011000100001110101011000110000111000000110011000001011111010111000100010110101100101010111111000"
        # message_11 = "1000110101000000011000100001110101011000110000111000010111100110101110111111001101001111011001010001000011010000"
        # message_12 = "1000110101000000011000100001110101011000110000111000001100000011101110001010111001011011010110010101111001011011"
        # message_13 = "1000110101000000011000100001110101011000110000111000011001101110010101101001101101001100011111010111101111100110"
        # message_14 = "1000110101000000011000100001110101011000110000111000000110011000001011111010111000100010110101100101010111111000"
        # message_15 = "1000110101000000011000100001110101011000110000111000010111100110101110111111001101001111011001010001000011010000"
        # message_16 = "1000110101000000011000100001110101011000110000111000001011101010010101101111101011010100100101000111011100011010"
        # message_17 = "1000110101000000011000100001110101011000110000111000011001010101011000101111001111011110000001001111111011010011"
        # message_18 = "1000110101000000011000100001110101011000110000111000000110011000001011111010111000100010110101100101010111111000"
        # message_19 = "1000110101000000011000100001110101011000110000111000010111100110101110111111001101001111011001010001000011010000"
        # message_20 = "1000110101000000011000100001110101011000110000111000000110001101100110111011010010110011110111000100010001001101"
        # message_21 = "1000110101000000011000100001110101011000110000111000010111011100010100111111100111000000011100101010100011000101"
        #
        #
        #
        # print("TAMANHO: ", len(decoded_message))
        # if decoded_message.find(message_1) != -1:
        #     print("1 PACOTE ACHADO")
        #
        # if decoded_message.find(message_2) != -1:
        #     print("2 PACOTE ACHADO")
        #
        # if decoded_message.find(message_3) != -1:
        #     print("3 PACOTE ACHADO")
        #
        # if decoded_message.find(message_4) != -1:
        #     print("4 PACOTE ACHADO")
        #
        # if decoded_message.find(message_5) != -1:
        #     print("5 PACOTE ACHADO")
        #
        # if decoded_message.find(message_6) != -1:
        #     print("6 PACOTE ACHADO")
        #
        # if decoded_message.find(message_7) != -1:
        #     print("7 PACOTE ACHADO")
        #
        # if decoded_message.find(message_8) != -1:
        #     print("8 PACOTE ACHADO")
        #
        # if decoded_message.find(message_9) != -1:
        #     print("9 PACOTE ACHADO")
        #
        # if decoded_message.find(message_10) != -1:
        #     print("10 PACOTE ACHADO")
        #
        # if decoded_message.find(message_11) != -1:
        #     print("11 PACOTE ACHADO")
        #
        # if decoded_message.find(message_12) != -1:
        #     print("12 PACOTE ACHADO")
        #
        # if decoded_message.find(message_13) != -1:
        #     print("13 PACOTE ACHADO")
        #
        # if decoded_message.find(message_14) != -1:
        #     print("14 PACOTE ACHADO")
        #
        # if decoded_message.find(message_15) != -1:
        #     print("15 PACOTE ACHADO")
        #
        # if decoded_message.find(message_16) != -1:
        #     print("16 PACOTE ACHADO")
        #
        # if decoded_message.find(message_17) != -1:
        #     print("17 PACOTE ACHADO")
        #
        # if decoded_message.find(message_18) != -1:
        #     print("18 PACOTE ACHADO")
        #
        # if decoded_message.find(message_19) != -1:
        #     print("19 PACOTE ACHADO")
        #
        # if decoded_message.find(message_20) != -1:
        #     print("20 PACOTE ACHADO")
        #
        # if decoded_message.find(message_21) != -1:
        #     print("21 PACOTE ACHADO")

        # print('Outputted {} items.'.format(L_payload))

        # output_items[0][:L_payload] = input_items[0][:L_payload]
        # self.consume(0, L_payload)
        #
        # self.mode = 'find'
        #
        # return len(decoded_message)

    def general_work_find(self, input_items, output_items):
        L_in = len(input_items[0])

        if L_in &lt; 5000 :
            return 0

        filter = np.array(np.ones(6), dtype=np.int)

        access_code_binary = np.array([int(b) for b in self.access_code], dtype=np.int)
        access_code_binary = np.convolve(access_code_binary, filter)

        input_decoded = np.array(input_items[0] , dtype=np.float32)

        corr = np.correlate(input_decoded, access_code_binary)
        corr = corr.tolist()

        max_corr = max(corr)

        if max_corr &gt; 96:
            match = True
        else:
            match = False

        if not match:
            self.consume(0, L_in - len(self.access_code))
        else:
            self.consume(0, len(self.access_code))
            self.mode = 'output'
            # correlation_index = corr.index(max(corr)) + 96
            # print(correlation_index)
            # final_index = correlation_index + self.payload_length
            #
            # output_index = final_index - correlation_index
            #
            # n_sample = 6
            # samples = ''
            # sample_counter = 0
            # decoded_message = ''
            #
            # velho = open("input_items.txt", "w+")
            # for input in input_items[0]:
            #     velho.write(str(input.astype(int)))
            #
            # velho.close()
            #
            #
            # for index in range(n_sample/2 , len(input_items[0][correlation_index:final_index]), n_sample):
            #     if input_items[0][correlation_index + index] &gt; 0.5:
            #         samples = samples + '1'
            #     else:
            #         samples = samples + '0'
            #
            # for index in range(0, 223, 2):
            #     if samples[index] == '0' and samples[index + 1] == '1':
            #         decoded_message = decoded_message + '0'
            #     else:
            #         decoded_message = decoded_message + '1'
            #
            # # print("DECODED_MESSAGE:    ", decoded_message)
            #
            # decoded_message_hex = hex(int(decoded_message, 2))
            # decoded_message_hex = decoded_message_hex[2:-1]
            #
            # type_code = adsb_dec.typecode(decoded_message_hex)
            #
            # if type_code &lt; 1 or type_code &gt; 4:
            #     pass
            # else:
            #     self.category = adsb_dec.category(decoded_message_hex)
            #     self.callsign = adsb_dec.callsign(decoded_message_hex)
            #
            # if (9 &lt;= type_code &lt;= 18 and 9 &lt;= type_code &lt;= 18):
            #     if self.position_message:
            #         self.position = adsb_dec.airborne_position(self.position_message, decoded_message_hex, 1, 2)
            #         self.position_message = ''
            #     else:
            #         self.position_message = decoded_message_hex
            # else:
            #     pass
            #
            # print("CATEGORY: " + str(self.category) + "          CALLSIGN: " + str(self.callsign) + "          POSITION: " + str(self.position))
            #
            # output_items[0][:len(input_items[0][correlation_index:final_index])] = input_items[0][correlation_index:final_index]
            #
            # self.consume(0, len(input_items[0]))
            #
            # return len(output_items[0])


        return 0
</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>payload_length</key><value>224*6</value></param>
<param><key>threshold</key><value>0</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>epy_block_1_0</value></param>
<param><key>_source_code</key><value>"""
Embedded Python Blocks:

Each time this file is saved, GRC will instantiate the first class it finds
to get ports and parameters of your block. The arguments to __init__  will
be the parameters. All of them are required to have default values!
"""

import numpy as np
from gnuradio import gr


class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
    """Embedded Python Block example - a simple multiply const"""

    def __init__(self, example_param=1.0):  # only default arguments here
        """arguments to this function show up as parameters in GRC"""
        gr.sync_block.__init__(
            self,
            name='SNIFFER',   # will show up in GRC
            in_sig=[np.int8],
            out_sig=[]
        )
        # if an attribute with the same name as a parameter is found,
        # a callback is registered (properties work, too).
        self.example_param = example_param


    # def forecast(self, noutput_items, ninput_items_required):
    #     ninput_items_required = 14

    def work(self, input_items, output_items):
        """example: multiply with constant"""

        self.consume(0, 8)
        return 0
</value></param>
<param><key>example_param</key><value>1.0</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>epy_block_2</value></param>
<param><key>_source_code</key><value>"""
Embedded Python Blocks:

Each time this file is saved, GRC will instantiate the first class it finds
to get ports and parameters of your block. The arguments to __init__  will
be the parameters. All of them are required to have default values!
"""

import numpy as np
from gnuradio import gr
import adsb_dec

class blk(gr.basic_block):
    """Embedded Python Block example - a simple multiply const"""

    def __init__(self):
        """arguments to this function show up as parameters in GRC"""
        gr.basic_block.__init__(
            self,
            name='Decoder',
            in_sig=[np.uint32],
            out_sig=[np.uint8]
        )
        self.preambule = '1010000101000000'
        self.int_to_return = []
        self.leftover = ''
        self.position_message = ''

        self.callsign = ''
        self.category = ''
        self.position = ''

    def forecast(self, noutput_items, ninput_items_required):
        ninput_items_required = 2000

    def general_work(self, input_items, output_items):

        if len(input_items[0]) &lt; 2000:
            return 0


        if not self.int_to_return:
            n_sample = 6
            samples = ''

            sample_counter = 0
            for index in range(n_sample/2, len(input_items[0]) - 1, n_sample):
            # ~for index in range(0, len(input_items[0]) - 1):

                samples = samples + str((input_items[0][index]))
                sample_counter = sample_counter + 1


            samples = self.leftover + samples


            ppm_array = ''
            decoded_message = ''
            if samples.find(self.preambule) != -1:

                start_preambule = samples.find(self.preambule)
                start_data = start_preambule + len(self.preambule)

                for i in range(start_data, start_data + 224):
                    ppm_array = ppm_array + samples[i]

                for index in range(0, 223, 2):
                    if ppm_array[index] == '0' and ppm_array[index + 1] == '1':
                        decoded_message = decoded_message + '0'
                    else:
                        decoded_message = decoded_message + '1'

                self.leftover = samples[0:start_preambule] + samples[start_data:]


                # message_1 = "1000110101000000011000100001110100100000000110001100011001000100010101010100000011001000101010001101100111010110"
                # message_2 = "1000110101000000011000100001110101011000110000111000000110011000001011111010111000100010110101100101010111111000"
                # message_3 = "1000110101000000011000100001110101011000110000111000010111100110101110111111001101001111011001010001000011010000"
                # message_4 = "1000110101000000011000100001110101011000110000111000001111111001101010010111110011110100001111110000010010010111"
                # message_5 = "1000110101000000011000100001110101011000110000111000010001001111000111011100010111001110111011011101100000100110"
                # message_6 = "1000110101000000011000100001110101011000110000111000000110011000001011111010111000100010110101100101010111111000"
                # message_7 = "1000110101000000011000100001110101011000110000111000010111100110101110111111001101001111011001010001000011010000"
                # message_8 = "1000110101000000011000100001110101011000110000111000001000101111001010111010101000010111110011110001100001010011"
                # message_9 = "1000110101000000011000100001110101011000110000111000011010011101010101011011011100011000101000110101011111110011"
                # message_10 = "1000110101000000011000100001110101011000110000111000000110011000001011111010111000100010110101100101010111111000"
                # message_11 = "1000110101000000011000100001110101011000110000111000010111100110101110111111001101001111011001010001000011010000"
                # message_12 = "1000110101000000011000100001110101011000110000111000001100000011101110001010111001011011010110010101111001011011"
                # message_13 = "1000110101000000011000100001110101011000110000111000011001101110010101101001101101001100011111010111101111100110"
                # message_14 = "1000110101000000011000100001110101011000110000111000000110011000001011111010111000100010110101100101010111111000"
                # message_15 = "1000110101000000011000100001110101011000110000111000010111100110101110111111001101001111011001010001000011010000"
                # message_16 = "1000110101000000011000100001110101011000110000111000001011101010010101101111101011010100100101000111011100011010"
                # message_17 = "1000110101000000011000100001110101011000110000111000011001010101011000101111001111011110000001001111111011010011"
                # message_18 = "1000110101000000011000100001110101011000110000111000000110011000001011111010111000100010110101100101010111111000"
                # message_19 = "1000110101000000011000100001110101011000110000111000010111100110101110111111001101001111011001010001000011010000"
                # message_20 = "1000110101000000011000100001110101011000110000111000000110001101100110111011010010110011110111000100010001001101"
                # message_21 = "1000110101000000011000100001110101011000110000111000010111011100010100111111100111000000011100101010100011000101"
                #
                #
                #
                # if decoded_message == message_1:
                #     print("1 PACOTE ACHADO")
                #
                # if decoded_message == message_2:
                #     print("2 PACOTE ACHADO")
                #
                # if decoded_message == message_3:
                #     print("3 PACOTE ACHADO")
                #
                # if decoded_message == message_4:
                #     print("4 PACOTE ACHADO")
                #
                # if decoded_message == message_5:
                #     print("5 PACOTE ACHADO")
                #
                # if decoded_message == message_6:
                #     print("6 PACOTE ACHADO")
                #
                # if decoded_message == message_7:
                #     print("7 PACOTE ACHADO")
                #
                # if decoded_message == message_8:
                #     print("8 PACOTE ACHADO")
                #
                # if decoded_message == message_9:
                #     print("9 PACOTE ACHADO")
                #
                # if decoded_message == message_10:
                #     print("10 PACOTE ACHADO")
                #
                # if decoded_message == message_11:
                #     print("11 PACOTE ACHADO")
                #
                # if decoded_message == message_12:
                #     print("12 PACOTE ACHADO")
                #
                # if decoded_message == message_13:
                #     print("13 PACOTE ACHADO")
                #
                # if decoded_message == message_14:
                #     print("14 PACOTE ACHADO")
                #
                # if decoded_message == message_15:
                #     print("15 PACOTE ACHADO")
                #
                # if decoded_message == message_16:
                #     print("16 PACOTE ACHADO")
                #
                # if decoded_message == message_17:
                #     print("17 PACOTE ACHADO")
                #
                # if decoded_message == message_18:
                #     print("18 PACOTE ACHADO")
                #
                # if decoded_message == message_19:
                #     print("19 PACOTE ACHADO")
                #
                # if decoded_message == message_20:
                #     print("20 PACOTE ACHADO")
                #
                # if decoded_message == message_21:
                #     print("21 PACOTE ACHADO")


                decoded_message_hex = hex(int(decoded_message, 2))
                decoded_message_hex = decoded_message_hex[2:-1]

                type_code = adsb_dec.typecode(decoded_message_hex)



                # print("TYPE CODE: ", type_code)
                # print("TAMANHO PACOTE: ", decoded_message_hex)

                if type_code &lt; 1 or type_code &gt; 4:
                    pass
                else:
                    self.category = adsb_dec.category(decoded_message_hex)
                    self.callsign = adsb_dec.callsign(decoded_message_hex)

                if (9 &lt;= type_code &lt;= 18 and 9 &lt;= type_code &lt;= 18):
                    if self.position_message:
                        self.position = adsb_dec.airborne_position(self.position_message, decoded_message_hex, 1, 2)
                        self.position_message = ''
                    else:
                        self.position_message = decoded_message_hex
                else:
                    pass

                print("CATEGORY: " + str(self.category) + "          CALLSIGN: " + str(self.callsign) + "          POSITION: " + str(self.position))
                chunks = [decoded_message[i:i+8] for i in range(0, len(decoded_message), 8)]
                list_int = [int(x, 2) for x in chunks]
                self.int_to_return = list_int
                output_items[0][0] = self.int_to_return.pop(0)




                self.consume(0, len(input_items[0]))
                return 1

            else:
                self.leftover = samples

                self.consume(0, len(input_items[0]))
                return 0
        else:
            if self.int_to_return:
                output_items[0][0] = self.int_to_return.pop(0)
                return 1
</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>fir_filter_xxx</key>
<param><key>id</key><value>fir_filter_xxx_0</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>taps</key><value>np.ones(6)/6</value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>fir_filter_xxx</key>
<param><key>id</key><value>fir_filter_xxx_0_0</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>taps</key><value>np.ones(6)/6</value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import numpy as np</value></param>
</block>
<block>
<key>interp_fir_filter_xxx</key>
<param><key>id</key><value>interp_fir_filter_xxx_0</value></param>
<param><key>interp</key><value>sps</value></param>
<param><key>taps</key><value>np.ones(sps)</value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>osmosdr_sink</key>
<param><key>id</key><value>osmosdr_sink_0</value></param>
<param><key>bb_gain0</key><value>30</value></param>
<param><key>corr0</key><value>freq_corr</value></param>
<param><key>freq0</key><value>fc - 10e3</value></param>
<param><key>if_gain0</key><value>30</value></param>
<param><key>gain0</key><value>30</value></param>
<param><key>args</key><value></value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>12000000</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>ppm_mapper</value></param>
<param><key>_source_code</key><value>import numpy as np
from gnuradio import gr


class blk(gr.interp_block):

    def __init__(self):
        gr.interp_block.__init__(
            self,
            name='PPM mapper',
            in_sig=[np.int8],
            out_sig=[np.int32],
            interp=2
        )

    def work(self, input_items, output_items):
        for i, b in enumerate(input_items[0]):
            output_items[0][2*i] = b
            output_items[0][2*i + 1] = not b
        return len(output_items[0])
</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>marker1</key><value>0</value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>size</key><value>2048</value></param>
<param><key>srate</key><value>12000000</value></param>
<param><key>tr_mode</key><value>qtgui.TRIG_MODE_AUTO</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>0.05</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0_1</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>marker1</key><value>0</value></param>
<param><key>size</key><value>2048</value></param>
<param><key>srate</key><value>12000000</value></param>
<param><key>tr_mode</key><value>qtgui.TRIG_MODE_AUTO</value></param>
<param><key>type</key><value>float</value></param>
<param><key>update_time</key><value>0.05</value></param>
<param><key>ymax</key><value>0.05</value></param>
<param><key>ymin</key><value>0</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0</value></param>
<param><key>decim</key><value>int(2.88e6)</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>interp</key><value>int(12e6)</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>rtlsdr_source</key>
<param><key>id</key><value>rtlsdr_source_0</value></param>
<param><key>bb_gain0</key><value>30</value></param>
<param><key>freq0</key><value>fc - 10e3</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>if_gain0</key><value>30</value></param>
<param><key>gain0</key><value>30</value></param>
<param><key>args</key><value></value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>2.88e6</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0</value></param>
<param><key>stream_id</key><value>virtual</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0</value></param>
<param><key>stream_id</key><value>virtual</value></param>
</block>
<connection><source_block_id>analog_const_source_x_0</source_block_id><sink_block_id>blocks_stream_mux_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_0</source_block_id><sink_block_id>fir_filter_xxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_0</source_block_id><sink_block_id>rational_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_int_0</source_block_id><sink_block_id>epy_block_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_int_to_float_0</source_block_id><sink_block_id>virtual_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0</source_block_id><sink_block_id>osmosdr_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_repack_bits_bb_0</source_block_id><sink_block_id>epy_block_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_repack_bits_bb_0</source_block_id><sink_block_id>ppm_mapper</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_mux_0</source_block_id><sink_block_id>blocks_int_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_0_0</source_block_id><sink_block_id>blocks_stream_mux_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>epy_block_0</source_block_id><sink_block_id>blocks_repack_bits_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>epy_block_1</source_block_id><sink_block_id>blocks_null_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>epy_block_2</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fir_filter_xxx_0</source_block_id><sink_block_id>epy_block_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fir_filter_xxx_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>interp_fir_filter_xxx_0</source_block_id><sink_block_id>blocks_float_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ppm_mapper</source_block_id><sink_block_id>blocks_stream_mux_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rtlsdr_source_0</source_block_id><sink_block_id>blocks_complex_to_mag_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0</source_block_id><sink_block_id>interp_fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
