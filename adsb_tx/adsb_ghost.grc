<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>adsb_ghost</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Rs</value></param>
<param><key>value</key><value>2e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fc</value></param>
<param><key>value</key><value>1090e6</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>freq_corr</value></param>
<param><key>value</key><value>0</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-100</value></param>
<param><key>step</key><value>0.5</value></param>
<param><key>stop</key><value>100</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>preamble</value></param>
<param><key>value</key><value>0xA140</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>12e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sps</value></param>
<param><key>value</key><value>int(samp_rate / Rs)</value></param>
</block>
<block>
<key>analog_const_source_x</key>
<param><key>id</key><value>analog_const_source_x_0</value></param>
<param><key>const</key><value>0</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>freq</key><value>10e3</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>blocks_complex_to_mag</key>
<param><key>id</key><value>blocks_complex_to_mag_0</value></param>
</block>
<block>
<key>blocks_float_to_complex</key>
<param><key>id</key><value>blocks_float_to_complex_0</value></param>
</block>
<block>
<key>blocks_int_to_float</key>
<param><key>id</key><value>blocks_int_to_float_0</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_repack_bits_bb</key>
<param><key>id</key><value>blocks_repack_bits_bb_0</value></param>
<param><key>k</key><value>8</value></param>
<param><key>l</key><value>1</value></param>
<param><key>endianness</key><value>gr.GR_MSB_FIRST</value></param>
</block>
<block>
<key>blocks_stream_mux</key>
<param><key>id</key><value>blocks_stream_mux_0</value></param>
<param><key>lengths</key><value>16, 2*112, 2000000</value></param>
<param><key>num_inputs</key><value>3</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>blocks_vector_source_x</key>
<param><key>id</key><value>blocks_vector_source_x_0_0</value></param>
<param><key>type</key><value>int</value></param>
<param><key>repeat</key><value>True</value></param>
<param><key>vector</key><value>tuple(int(x) for x in bin(preamble)[2:])</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>epy_block_0</value></param>
<param><key>_source_code</key><value>"""
Embedded Python Blocks:

Each time this file is saved, GRC will instantiate the first class it finds
to get ports and parameters of your block. The arguments to __init__  will
be the parameters. All of them are required to have default values!
"""

import numpy as np
import encoder
import util
from gnuradio import gr
from subprocess import call

MOVEMENT_CONST = 0.0001
class blk(gr.basic_block):  # other base classes are basic_block, decim_block, interp_block
    """Embedded Python Block example - a simple multiply const"""

    def __init__(self):  # only default arguments here
        """arguments to this function show up as parameters in GRC"""


        gr.basic_block.__init__(
            self,
            name='ADSB encoder',   # will show up in GRC
            in_sig=[],
            out_sig=[np.uint8]
        )

        # if an attribute with the same name as a parameter is found,
        # a callback is registered (properties work, too).

	self.int_to_return = []

    def travel(self, coordinates, alt, icao, current_latitude, current_longitude, plan = None):

        lat_list = []
        lon_list = []

        lat_list.append(current_latitude)
        lon_list.append(current_longitude)
        lat_list.append(current_latitude + MOVEMENT_CONST)
        lon_list.append(current_longitude + MOVEMENT_CONST)

        lat_list.append(coordinates['latitude'])
        lon_list.append(coordinates["longitude"])
        lat_list.append(coordinates["latitude"] + MOVEMENT_CONST)
        lon_list.append(coordinates["longitude"] + MOVEMENT_CONST)

        i = 0
        while i &lt; len(lat_list):
            coordenadas = encoder.cpr_encode(lat_list[i], lon_list[i], 0, 1)
            latitude = encoder.get_lat(coordenadas)
            longitude = encoder.get_long(coordenadas)
            message_position = encoder.aircraft_position('01011000', alt, latitude,
                                                         longitude, '0', icao)

            coordenadas = encoder.cpr_encode(lat_list[i+1], lon_list[i+1], 1, 1)
            latitude = encoder.get_lat(coordenadas)
            longitude = encoder.get_long(coordenadas)
            message_position1 = encoder.aircraft_position('01011000', alt, latitude,
                                                          longitude, '1', icao)
            plan.write(util.hex2bin(message_position))
            plan.write(util.hex2bin(message_position1))

            # coordenadas_dec = adsb_dec.position(message_position,
            #                                     message_position1, 1, 11)
            i = i + 2

    def general_work(self, input_items, output_items):
        if not self.int_to_return:
            icao = "40621D"
            alts = '110000111000'
            plan = open('/home/llucindov/dev/telecom/adsb-ghost/flight_plan_binary.txt', 'w+')
            lock = True
            current_latitude = -27.608339
            current_longitude = -48.633269
            flight_plan = open("flight_plan.txt","r")
            a = flight_plan.readlines()
            list_command = []
            list_value = []

            for i in range(len(a)):
                b = a[i].split(";")
                list_command.append(b[0])
                list_value.append(b[1].rstrip())

            while lock == True:
                for i in range(len(a)):
                    if i == (len(a) - 1):
                        lock = False

                    if list_command[i] == 'travel':
                        destiny_coordinates = list_value[i].split(",")
                        destiny_coordinates = {'latitude': float(destiny_coordinates[0]),
                                               'longitude': float(destiny_coordinates[1])}
                        self.travel(destiny_coordinates, alts, icao, current_latitude, current_longitude, plan)

                    if list_command[i] == 'name':
                        message = encoder.aircraft_id(icao, list_value[i])
                        plan.write(util.hex2bin(message))

                    # if list_command[i] == 'alt':
                    #     destiny_coordinates = {'latitude': current_latitude,'longitude': current_longitude}
                    #     alts = encoder.aircraft_altitude(int(list_value[i]))
                    #     self.travel(self, destiny_coordinates, alts, message, current_latitude, current_longitude, plan)

            plan.close()
            b = open('/home/llucindov/dev/telecom/adsb-ghost/flight_plan_binary.txt', "r")
            c = b.readlines()
            c = str(c)
            c = c[2:(len(c)-2)]
            chunks = [c[i:i+8] for i in range(0, len(c), 8)]
            list_int = [int(x, 2) for x in chunks]
            self.int_to_return = list_int
            output_items[0][0] = self.int_to_return.pop(0)
            return 1

        else:
            if self.int_to_return:
                output_items[0][0] = self.int_to_return.pop(0)
                return 1
</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>epy_block_2</value></param>
<param><key>_source_code</key><value>"""
Embedded Python Blocks:

Each time this file is saved, GRC will instantiate the first class it finds
to get ports and parameters of your block. The arguments to __init__  will
be the parameters. All of them are required to have default values!
"""

import numpy as np
from gnuradio import gr


class blk(gr.basic_block):  # other base classes are basic_block, decim_block, interp_block
    """Embedded Python Block example - a simple multiply const"""

    def __init__(self):  # only default arguments here
        """arguments to this function show up as parameters in GRC"""
        gr.basic_block.__init__(
            self,
            name='Decoder',   # will show up in GRC
            in_sig=[np.float32],
            out_sig=[np.float32]
        )
        # self.preambule = '1010000101000000'
        self.preambule = '1010000101000000'
        # if an attribute with the same name as a parameter is found,
        # a callback is registered (properties work, too).

    def general_work(self, input_items, output_items):

        if len(input_items[0]) &lt; 128:
            return 0

        retorno = 0
        n_sample = 6
        samples = ''
        samples_float = np.empty_like(input_items[0][::n_sample])

        for index in range(n_sample/2, len(input_items[0]) - 1, n_sample):
            if index &gt;= len(samples_float):
                break
            samples_float[index]= input_items[0][index]
            samples = samples + str((input_items[0][index].astype(int)))


        if samples.find(self.preambule) != -1:
            start_preambule = samples.find(self.preambule)
            start_data = start_preambule + len(self.preambule)

            for i in range(start_data, (len(samples) - len(self.preambule))):
                if int(samples_float[i].astype(int)) &gt;= 1:
                    output_items[0][retorno] = 1

                if int(samples_float[i].astype(int)) &lt;= 0:
                    output_items[0][retorno] = 0
                # output_items[0][retorno] = samples_float[i]
                # print(int(samples_float[i].astype(int)))
                retorno = retorno + 1

            return retorno

        else:
            print("DEU RUIM")
            return retorno
</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import numpy as np</value></param>
</block>
<block>
<key>interp_fir_filter_xxx</key>
<param><key>id</key><value>interp_fir_filter_xxx_0</value></param>
<param><key>interp</key><value>sps</value></param>
<param><key>taps</key><value>np.ones(sps)</value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>interp_fir_filter_xxx</key>
<param><key>id</key><value>interp_fir_filter_xxx_0_0</value></param>
<param><key>_enabled</key><value>2</value></param>
<param><key>interp</key><value>sps</value></param>
<param><key>taps</key><value>np.ones(sps)</value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>osmosdr_sink</key>
<param><key>id</key><value>osmosdr_sink_0</value></param>
<param><key>bb_gain0</key><value>30</value></param>
<param><key>corr0</key><value>freq_corr</value></param>
<param><key>freq0</key><value>fc - 10e3</value></param>
<param><key>if_gain0</key><value>30</value></param>
<param><key>gain0</key><value>0</value></param>
<param><key>args</key><value></value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>ppm_mapper</value></param>
<param><key>_source_code</key><value>import numpy as np
from gnuradio import gr


class blk(gr.interp_block):

    def __init__(self):
        gr.interp_block.__init__(
            self,
            name='PPM mapper',
            in_sig=[np.int8],
            out_sig=[np.int32],
            interp=2
        )

    def work(self, input_items, output_items):
        for i, b in enumerate(input_items[0]):
            output_items[0][2*i] = b
            output_items[0][2*i + 1] = not b
        return len(output_items[0])
</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>marker1</key><value>0</value></param>
<param><key>size</key><value>2048</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>tr_mode</key><value>qtgui.TRIG_MODE_AUTO</value></param>
<param><key>type</key><value>float</value></param>
<param><key>update_time</key><value>0.05</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>marker1</key><value>0</value></param>
<param><key>size</key><value>2048</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>tr_mode</key><value>qtgui.TRIG_MODE_AUTO</value></param>
<param><key>type</key><value>float</value></param>
<param><key>update_time</key><value>0.05</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0</value></param>
<param><key>stream_id</key><value>virtual</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0</value></param>
<param><key>stream_id</key><value>virtual</value></param>
</block>
<connection><source_block_id>analog_const_source_x_0</source_block_id><sink_block_id>blocks_stream_mux_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_0</source_block_id><sink_block_id>epy_block_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_0</source_block_id><sink_block_id>blocks_complex_to_mag_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_int_to_float_0</source_block_id><sink_block_id>virtual_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0</source_block_id><sink_block_id>osmosdr_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_repack_bits_bb_0</source_block_id><sink_block_id>ppm_mapper</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_mux_0</source_block_id><sink_block_id>blocks_int_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_0_0</source_block_id><sink_block_id>blocks_stream_mux_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>epy_block_0</source_block_id><sink_block_id>blocks_repack_bits_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>epy_block_2</source_block_id><sink_block_id>interp_fir_filter_xxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>interp_fir_filter_xxx_0</source_block_id><sink_block_id>blocks_float_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>interp_fir_filter_xxx_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>interp_fir_filter_xxx_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ppm_mapper</source_block_id><sink_block_id>blocks_stream_mux_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>virtual_source_0</source_block_id><sink_block_id>interp_fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
